*title

R1 2 0 2
I1 0 2 2
R2 1 2 4
V1 1 0 3
.OPTIONS ITER

*.DC v1 0 4 0.5

*.plot v(1)
*.plot v(2)
